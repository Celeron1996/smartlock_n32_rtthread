# Keil uVision project UART_DEVICE_REGISTER.uvprojx, settings and files
target N32L40x (6180000::V6.18::ARMCLANG)
  device: N32L406RB Nationstech
  pack: Nationstech.N32L40x_DFP.1.0.1
  cpu: IRAM(0x20000000,0x6000) IROM(0x08000000,0x20000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: UART_DEVICE_REGISTER
  AfterMake: fromelf --bin --output=.\bin\UART_DEVICE_REGISTER.bin .\Objects\UART_DEVICE_REGISTER.axf
  c flags: Optim=2 v6Lang=1 v6LangP=5 wLevel=3
  c define: N32L40X, USE_STDPERIPH_DRIVER
  c include: ..\..\..\..\..\..\firmware\CMSIS\core;..\..\..\..\..\..\firmware\CMSIS\device;..\..\..\..\..\..\firmware\n32l40x_std_periph_driver\inc;..\..\..\..\..\..\middlewares\rt-thread\include;..\..\..\..\..\..\middlewares\rt-thread\components\drivers\include\drivers;..\..\..\..\..\..\middlewares\rt-thread\components\drivers\include\ipc;..\..\..\..\..\..\middlewares\rt-thread\components\drivers\include;..\..\DeviceDrivers\gpio\inc;..\..\DeviceDrivers\uart\inc;..\inc;..\..\DeviceDrivers\finger\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x6000
  group STARTUP
    ../../../../../../firmware/CMSIS/device/startup/: startup_n32l40x.s
  group CMSIS
    ../../../../../../firmware/CMSIS/device/: system_n32l40x.c
  group FWLB
    ../../../../../../firmware/n32l40x_std_periph_driver/src/: misc.c n32l40x_exti.c n32l40x_gpio.c n32l40x_rcc.c n32l40x_usart.c
  group RT_Thread
    ../../../../../../middlewares/rt-thread/src/: clock.c components.c cpu.c device.c idle.c ipc.c irq.c kservice.c mem.c memheap.c mempool.c object.c scheduler.c signal.c slab.c thread.c timer.c
  group CORTEX-M4
    ../../../../../../middlewares/rt-thread/libcpu/cortex-m4/: context_rvds.S cpuport.c
  group USER
    ../src/: board.c main.c n32l40x_it.c finger_app.c event_manager.c mypm.c
  group Device_Drivers
    ../../DeviceDrivers/uart/src/: drv_usart.c
    ../../DeviceDrivers/finger/src/: fm01_drv.c fm01_bsp.c
  group Drivers
    ../../../../../../middlewares/rt-thread/components/drivers/misc/: pin.c
    ../../../../../../middlewares/rt-thread/components/drivers/serial/: serial.c
    ../../../../../../middlewares/rt-thread/components/drivers/src/: completion.c
    ../../DeviceDrivers/finger/src/: finger.c
  group DOC
    ../: readme.txt
